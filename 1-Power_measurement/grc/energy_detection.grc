options:
  parameters:
    generate_options: qt_gui
    id: energy_detection
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: px_rate*harmonic
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '5'
    value: '1'
  states: {}
- name: high_cut
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: samp_rate/2
    value: 4e6
  states: {}
- name: low_cut
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: samp_rate/2
    value: '20000'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,2
    label: Display's resolution
    labels: modes
    num_opts: '0'
    options: list(range(len(modes)))
    type: int
    value: '0'
  states: {}
- name: modes
  id: variable
  parameters:
    value: '[''3840x2160@30.0'', ''4096x2160@30.0'', ''4096x2160@25.0'', ''4096x2160@24.0'', ''4096x2160@29.97'', ''4096x2160@23.98'', ''3840x2160@25.0'', ''3840x2160@24.0'', ''3840x2160@29.97'', ''3840x2160@23.98'', ''1920x1080@60.0'', ''1920x1080@50.0'', ''1920x1080@59.94'', ''1920x1080@30.0'', ''1920x1080@25.0'', ''1920x1080@24.0'', ''1920x1080@29.97'', ''1920x1080@23.98'', ''1280x1024@60.02'', ''1280x960@60.0'', ''1280x720@60.0'', ''1280x720@50.0'', ''1280x720@59.94'', ''1024x768@60.0'', ''800x600@60.32'', ''720x576@50.0'', ''720x480@60.0'', ''720x480@59.94'', ''640x480@60.0'', ''640x480@59.94'']'
  states: {}
- name: px_clocks
  id: variable
  parameters:
    value: '[297000000, 297000000, 297000000, 297000000, 296703000, 296752500, 297000000, 297000000, 296703000, 296752500, 148500000, 148500000, 148351500, 74250000, 74250000, 74250000, 74175750, 74188125, 108000468, 108000000, 74250000, 74250000, 74175750, 64995840, 40002293, 27000000, 27027000, 26999973, 25200000, 25174800]'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: px_clocks[mode]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_cut
    low_cutoff_freq: low_cut
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
