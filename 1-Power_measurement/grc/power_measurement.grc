options:
  parameters:
    generate_options: qt_gui
    id: power_measurement
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Io
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bw
  id: variable_qtgui_chooser
  parameters:
    label: BW
    label0: 8e6
    label1: 4e6
    label2: 2e6
    label3: 2500Hz
    num_opts: '4'
    option0: 4e6
    option1: 2e6
    option2: 1e6
    option3: 202.5e3
    type: real
    value: 4e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 1e6
    stop: 1e9
    value: 140e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: meting_level
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Signal niveau (dbm)
    type: real
    value: variable_function_probe_0 + 30
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: '20e-6'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_KAISER
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 4e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_KAISER
  states: {}
- name: meting_level
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '12'
    clock_source0: internal
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', meting_level, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', high_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
