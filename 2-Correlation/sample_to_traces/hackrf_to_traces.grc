options:
  parameters:
    generate_options: qt_gui
    id: hackrf_to_traces
    output_language: python
    title: hackrf_to_traces
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: px_clock*harmonic
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '10'
    value: '4'
  states: {}
- name: px_clock
  id: variable
  parameters:
    value: 148.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data.bin
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_file_sink_0, '0']
- [blocks_correctiq_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_correctiq_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_1, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
