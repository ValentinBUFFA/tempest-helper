options:
  parameters:
    generate_options: qt_gui
    id: manual_simulated_tempest_example
    output_language: python
  states: {}

blocks:
- name: Hdisplay
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '800'
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '768'
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: '624'
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '600'
  states: {}
- name: decim
  id: variable
  parameters:
    value: inter
  states: {}
- name: epsilon_channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sampling error
    start: '-0.1'
    step: '10e-6'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency Error (normalized)
    start: '-1'
    step: '1e-5'
    stop: '1'
    value: '0'
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Harmonic
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Horizontal offset
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: inter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*usrp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Vertical offset
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Power
    start: '0'
    step: '1e-4'
    stop: '2e-2'
    value: '1e-3'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: rectangular_pulse
  id: variable
  parameters:
    value: '[0.7/255]*inter'
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: px_rate*inter
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(30e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: px_rate*harmonic
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data.bin
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon_channel+1
    freq_offset: freq
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: genero la forma de onda en el cable
    interp: inter
    taps: rectangular_pulse
    type: fcc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: usrp_rate
    taps: ''
    type: ccc
  states: {}
- name: tempest_image_source_0
  id: tempest_image_source
  parameters:
    Htotal: '1024'
    Hvisible: '800'
    Vtotal: '624'
    Vvisible: '600'
    image_file: Imagen_800_600.png
    repeatmode: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '0']
- [channels_channel_model_0, '0', blocks_complex_to_mag_squared_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']
- [tempest_image_source_0, '0', interp_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
